# IAR project BasicUSART_USB.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8f.h
  General.OGChipSelectEditMenu: AT91SAM7SE512 Atmel AT91SAM7SE512
  ICCARM.CCIncludePath2: srcIAR\; ..\src\; ..\..\; ..\..\kalman; ..\..\pcm; ..\..\spi; ..\..\timer; ..\..\pid
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: ..\..\
  XLINK.XclFile: Resource\AT91SAM7SE512_RAM.xcl
configuration FLASH_Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePath2: srcIAR\; ..\src\; ..\..\; ..\..\kalman; ..\..\pcm; ..\..\spi; ..\..\timer; ..\..\pid; ..\..\avcs
  XLINK.XclFile: resource\at91SAM7SE512_FLASH.xcl
configuration Binary (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  ICCARM.CCIncludePath2: srcIAR\; ..\src\; ..\..\; ..\..\kalman; ..\..\pcm; ..\..\spi
  XLINK.XclFile: resource\at91SAM7SE512_FLASH.xcl
  group kalman
    ../../pid/: controller.c
    ../../EKF/: Filter.c Matrix.c
    ../../kalman/: gps.c imu.c mat.c
  group Resource
    Resource/: at91SAM7SE512_FLASH.xcl at91SAM7SE512_RAM.xcl SAM7_FLASH.mac SAM7_RAM.mac
  group src
    ../../avcs/: avcs.c
    ../../bmp/: bmp085.c
    ../src/: interrupt_Usart.c main.c
    ../../pcm/: pcm.c
    ../../spi/: spi.c
    ../../target/: target.c
    ../../timer/: timer.c
    ../../trajectory/: trajectory.c
    ../../twi/: twi.c
  group srcIAR
    srcIAR/: Cstartup.s79 Cstartup_SAM7.c
